# Keil uVision project eMouse_C.uvprojx, settings and files
target CMSIS-DAP (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: eMouse_C
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group src
    ./: main.c sLCD.c sLCD.h I2C.c I2C.h MMA8451.c MMA8451.h uart.c uart.h buttons.c buttons.h
  group ::Device
    RTE/Device/MKL46Z256xxx4/: startup_MKL46Z4.s system_MKL46Z4.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
